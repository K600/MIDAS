# Keil uVision project subm_260.uvproj, settings and files
target Download (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000)
  output: subm_260 +hex
  BeforeMake: c:\mscb\makegit.bat
  c flags: Optimize=9
  c include: ..\include;\mscb;
  group Source Files
    ./: subm_260.c config.h
    ../src/: mscbutil.c
  group Header Files
    ../include/: mscbemb.h net.h
    ../../: git-revision.h
  group Libraries
    ../lib/: netlib.lib
target Simulation (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000)
  output: subm_260 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SUBM_260
  c include: \midas\mscb\embedded
