# Keil uVision project hvr_800.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: hvr_800 +hex
  c flags: Optimize=9
  c include: ..\include;..\..\;
  group Source Group 1
    ./: hvr_800.c config.h
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ../include/: mscbemb.h
    ../../: git-revision.h
