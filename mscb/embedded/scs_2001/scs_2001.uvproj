# Keil uVision project scs_2001.uvproj, settings and files
target ICE (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000)
  output: scs_2001 +hex
  BeforeMake: \mscb\makegit.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;\mscb
  group Source Files
    ./: scs_2001.c scs_2001_lib.c rtc.c lcd_menu.c monitor.c lcd.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: scs_2001.h config.h lcd.h
    ../include/: mscbemb.h
    ../../: git-revision.h
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_500
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_500
